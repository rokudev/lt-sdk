/*******************************************************************************
 * Device Crypto Unit Test
 *
 * This Source Code Form is subject to the terms of the Mozilla Public License, v. 2.0.
 * If a copy of the MPL was not distributed with this file, you can obtain one at
 * https://mozilla.org/MPL/2.0/.
 *
 * Copyright 2026, Roku, Inc.  All rights reserved.
 ******************************************************************************/

#include <lt/LTTypes.h>
#include <lt/device/identity/LTDeviceIdentity.h>
#include <lt/driver/crypto/LTDriverCrypto.h>
#include <lt/system/crypto/LTSystemCrypto.h>
#include <lt/system/settings/LTSystemSettings.h>
#include <lt/net/x509/LTNetX509.h>
#include <tilt/JiltEngine.h>

static JiltEngine       *s_engine;
static LTSystemCrypto   *s_crypto;
static LTSystemSettings *s_settings;

/*******************************************************************************
 * Test Functions
 ******************************************************************************/

static void PrintBytes(Tilt *tilt, u8 *buf, int start, int length) {
    for (int i = start; i < start + length; i += 16) {
        TILT_DEBUG(tilt, "%d/%d:%02X%02X%02X%02X%02X%02X%02X%02X%02X%02X%02X%02X%02X%02X%02X%02X",
                     i, length, buf[i],   buf[i+1], buf[i+2],  buf[i+3],  buf[i+4],  buf[i+5],  buf[i+6],  buf[i+7],
                                buf[i+8], buf[i+9], buf[i+10], buf[i+11], buf[i+12], buf[i+13], buf[i+14], buf[i+15]);
    }
}

static const u8 k78[]  =  {0xef,0x30,0xa7,0x8d,0x33,0xa2,0x04,0x72,0xd8,0x88,0xb6,0x59,0x0a,0x4a,0xb1,0xba};
static const u8 iv78[] =  {0x19,0x67,0xb3,0xbb,0x29,0xd6,0xcc,0x39,0xc0,0x5d,0x6d,0x45,0x64,0xcc,0x81,0xb8};
static const u8 p78[]  =  {0x87,0x51,0x88,0x02,0xb6,0xe9,0x5a,0x9a,0xd4,0x40,0x16,0x14,0xe2,0x18,0xe9,0x5b,
                           0xcf,0x9e,0x41,0x8a,0xb7,0x93,0xf5,0x06,0xa4,0x04,0xed,0x84,0x4f,0x19,0x58,0xd9,
                           0x4b,0xf1,0x39,0xfe,0x0e,0x80,0x62,0x15,0xc9,0x13,0x22,0x95,0x79,0xdd,0x17,0x40,
                           0x56,0x1f,0x39,0xa4,0x60,0xc3,0xf8,0xc4,0x53,0x04,0x69,0x26,0x14,0x6a,0x2c,0xcc};
static const u8 ec78[] =  {0xb0,0x55,0x1c,0x83,0xa3,0xe8,0x8b,0x12,0x37,0x67,0x7f,0x79,0x75,0x77,0x4f,0x50,
                           0x31,0xac,0x5a,0x60,0xae,0xee,0xae,0x1b,0xc2,0x84,0x72,0xd1,0xbd,0xe3,0xc7,0xde,
                           0x9a,0x48,0xb3,0x2e,0x9a,0x09,0x41,0xf8,0x0a,0x72,0x09,0x84,0x7b,0x64,0x82,0xe1,
                           0x74,0xf4,0xe4,0xcb,0x85,0xd5,0xa1,0x97,0xe2,0xe5,0x62,0x0e,0xc3,0xf3,0xd4,0x50};
static u8 s_output[128];

#if 0
/* Real Roku CA
 * MIIB0TCCAXegAwIBAgICUAEwCgYIKoZIzj0EAwIwPzELMAkGA1UEBhMCVVMxEzARBgNVBAoMClJva3UsIEluYy4xGzAZBgNVBAMMElJva3UgUm9vdCBDQSBFQzI1NjAeFw0yMzA0MTMxODQ5NTRaFw00MzA3MTcxODQ5NTRaMD8xCzAJBgNVBAYTAlVTMRMwEQYDVQQKDApSb2t1LCBJbmMuMRswGQYDVQQDDBJSb2t1IFJvb3QgQ0EgRUMyNTYwWTATBgcqhkjOPQIBBggqhkjOPQMBBwNCAAQ/DzLfrFFo2DiqXM/UkzBxtBnfdPBX0EvQhGoycO8aBEypgwW0wKfDobTaXM2Z2Uclyvl8HDUVbCU6r8fBW+2Do2MwYTAdBgNVHQ4EFgQUj747AVYCpSQU0Rj0NIQ0HIGFbaIwHwYDVR0jBBgwFoAUj747AVYCpSQU0Rj0NIQ0HIGFbaIwDwYDVR0TAQH/BAUwAwEB/zAOBgNVHQ8BAf8EBAMCAQYwCgYIKoZIzj0EAwIDSAAwRQIgCkcFKDyg5/h8dxKJSyWK6MZcLqmvxXzlec1izmGw/3wCIQDgtBn6guMR/woi/SWAfiTSrt8d57yDj0kVMvyNtEZF/g==
 */
static const u8 s_RokuCa[] = {
    0x30,0x82,0x01,0xd1,0x30,0x82,0x01,0x77,0xa0,0x03,0x02,0x01,0x02,0x02,0x02,0x50,0x01,0x30,0x0a,0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x04,0x03,0x02,0x30,0x3f,0x31,
    0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x06,0x13,0x02,0x55,0x53,0x31,0x13,0x30,0x11,0x06,0x03,0x55,0x04,0x0a,0x0c,0x0a,0x52,0x6f,0x6b,0x75,0x2c,0x20,0x49,0x6e,0x63,
    0x2e,0x31,0x1b,0x30,0x19,0x06,0x03,0x55,0x04,0x03,0x0c,0x12,0x52,0x6f,0x6b,0x75,0x20,0x52,0x6f,0x6f,0x74,0x20,0x43,0x41,0x20,0x45,0x43,0x32,0x35,0x36,0x30,0x1e,
    0x17,0x0d,0x32,0x33,0x30,0x34,0x31,0x33,0x31,0x38,0x34,0x39,0x35,0x34,0x5a,0x17,0x0d,0x34,0x33,0x30,0x37,0x31,0x37,0x31,0x38,0x34,0x39,0x35,0x34,0x5a,0x30,0x3f,
    0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x06,0x13,0x02,0x55,0x53,0x31,0x13,0x30,0x11,0x06,0x03,0x55,0x04,0x0a,0x0c,0x0a,0x52,0x6f,0x6b,0x75,0x2c,0x20,0x49,0x6e,
    0x63,0x2e,0x31,0x1b,0x30,0x19,0x06,0x03,0x55,0x04,0x03,0x0c,0x12,0x52,0x6f,0x6b,0x75,0x20,0x52,0x6f,0x6f,0x74,0x20,0x43,0x41,0x20,0x45,0x43,0x32,0x35,0x36,0x30,
    0x59,0x30,0x13,0x06,0x07,0x2a,0x86,0x48,0xce,0x3d,0x02,0x01,0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x03,0x01,0x07,0x03,0x42,0x00,0x04,0x3f,0x0f,0x32,0xdf,0xac,0x51,
    0x68,0xd8,0x38,0xaa,0x5c,0xcf,0xd4,0x93,0x30,0x71,0xb4,0x19,0xdf,0x74,0xf0,0x57,0xd0,0x4b,0xd0,0x84,0x6a,0x32,0x70,0xef,0x1a,0x04,0x4c,0xa9,0x83,0x05,0xb4,0xc0,
    0xa7,0xc3,0xa1,0xb4,0xda,0x5c,0xcd,0x99,0xd9,0x47,0x25,0xca,0xf9,0x7c,0x1c,0x35,0x15,0x6c,0x25,0x3a,0xaf,0xc7,0xc1,0x5b,0xed,0x83,0xa3,0x63,0x30,0x61,0x30,0x1d,
    0x06,0x03,0x55,0x1d,0x0e,0x04,0x16,0x04,0x14,0x8f,0xbe,0x3b,0x01,0x56,0x02,0xa5,0x24,0x14,0xd1,0x18,0xf4,0x34,0x84,0x34,0x1c,0x81,0x85,0x6d,0xa2,0x30,0x1f,0x06,
    0x03,0x55,0x1d,0x23,0x04,0x18,0x30,0x16,0x80,0x14,0x8f,0xbe,0x3b,0x01,0x56,0x02,0xa5,0x24,0x14,0xd1,0x18,0xf4,0x34,0x84,0x34,0x1c,0x81,0x85,0x6d,0xa2,0x30,0x0f,
    0x06,0x03,0x55,0x1d,0x13,0x01,0x01,0xff,0x04,0x05,0x30,0x03,0x01,0x01,0xff,0x30,0x0e,0x06,0x03,0x55,0x1d,0x0f,0x01,0x01,0xff,0x04,0x04,0x03,0x02,0x01,0x06,0x30,
    0x0a,0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x04,0x03,0x02,0x03,0x48,0x00,0x30,0x45,0x02,0x20,0x0a,0x47,0x05,0x28,0x3c,0xa0,0xe7,0xf8,0x7c,0x77,0x12,0x89,0x4b,0x25,
    0x8a,0xe8,0xc6,0x5c,0x2e,0xa9,0xaf,0xc5,0x7c,0xe5,0x79,0xcd,0x62,0xce,0x61,0xb0,0xff,0x7c,0x02,0x21,0x00,0xe0,0xb4,0x19,0xfa,0x82,0xe3,0x11,0xff,0x0a,0x22,0xfd,
    0x25,0x80,0x7e,0x24,0xd2,0xae,0xdf,0x1d,0xe7,0xbc,0x83,0x8f,0x49,0x15,0x32,0xfc,0x8d,0xb4,0x46,0x45,0xfe,
};

static const LTPublicKey s_RokuCaKey = {
    SIGNATURE_ECDSA_SECP256R1_SHA256,
    ECDSA_P256_PUBLICKEY_LENGTH,
    (u8 *)"\x3f\x0f\x32\xdf\xac\x51\x68\xd8\x38\xaa\x5c\xcf\xd4\x93\x30\x71\xb4\x19\xdf\x74\xf0\x57\xd0\x4b\xd0\x84\x6a\x32\x70\xef\x1a\x04\x4c\xa9\x83\x05\xb4\xc0\xa7\xc3\xa1\xb4\xda\x5c\xcd\x99\xd9\x47\x25\xca\xf9\x7c\x1c\x35\x15\x6c\x25\x3a\xaf\xc7\xc1\x5b\xed\x83",
    SHA1_HASH_LENGTH,
    (u8 *)"\x8F\xBE\x3B\x01\x56\x02\xA5\x24\x14\xD1\x18\xF4\x34\x84\x34\x1C\x81\x85\x6D\xA2",
};

#else

/* Test server CA (pretend to be Roku CA)
 * MIICDTCCAbSgAwIBAgIUbY8nPXgD5Kf8LTYX+6euzkOYGGwwCgYIKoZIzj0EAwIwPzELMAkGA1UEBhMCVVMxDTALBgNVBAoMBFJva3UxCzAJBgNVBAsMAkxUMRQwEgYDVQQDDAtsdC5yb2t1LmNvbTAgFw0yMzA0MTExNjIxMTBaGA8yMDUwMDgyNjE2MjExMFowPzELMAkGA1UEBhMCVVMxDTALBgNVBAoMBFJva3UxCzAJBgNVBAsMAkxUMRQwEgYDVQQDDAtsdC5yb2t1LmNvbTBZMBMGByqGSM49AgEGCCqGSM49AwEHA0IABOC70EVsCtEdWUbHL2apSlSjLA5BBYc4Og+Yeu21PyITi8LB2WPHPccw/nwHZ+S1zFVXh2vpPZ/uKy/fONRwpQKjgYswgYgwEgYDVR0TAQH/BAgwBgEB/wIBAjAdBgNVHQ4EFgQUq1xml+rIabE3W7CVP1k+e1VfEUswHwYDVR0jBBgwFoAUq1xml+rIabE3W7CVP1k+e1VfEUswHQYDVR0lBBYwFAYIKwYBBQUHAwEGCCsGAQUFBwMCMBMGA1UdEQQMMAqCCGx0c2VydmVyMAoGCCqGSM49BAMCA0cAMEQCIDXIfG9GI1A0qPFAhqcv18uqbsRx/PypnfE+JZ8fLr22AiBc9o3l7UycJIzCCUDZ8Jd02wCsratOZmXSujxKM4poRw==
 */
static const u8 s_RokuCa[] = {
    0x30,0x82,0x02,0x0d,0x30,0x82,0x01,0xb4,0xa0,0x03,0x02,0x01,0x02,0x02,0x14,0x6d,0x8f,0x27,0x3d,0x78,0x03,0xe4,0xa7,0xfc,0x2d,0x36,0x17,0xfb,0xa7,0xae,0xce,0x43,
    0x98,0x18,0x6c,0x30,0x0a,0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x04,0x03,0x02,0x30,0x3f,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x06,0x13,0x02,0x55,0x53,0x31,0x0d,
    0x30,0x0b,0x06,0x03,0x55,0x04,0x0a,0x0c,0x04,0x52,0x6f,0x6b,0x75,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x0b,0x0c,0x02,0x4c,0x54,0x31,0x14,0x30,0x12,0x06,0x03,
    0x55,0x04,0x03,0x0c,0x0b,0x6c,0x74,0x2e,0x72,0x6f,0x6b,0x75,0x2e,0x63,0x6f,0x6d,0x30,0x20,0x17,0x0d,0x32,0x33,0x30,0x34,0x31,0x31,0x31,0x36,0x32,0x31,0x31,0x30,
    0x5a,0x18,0x0f,0x32,0x30,0x35,0x30,0x30,0x38,0x32,0x36,0x31,0x36,0x32,0x31,0x31,0x30,0x5a,0x30,0x3f,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x06,0x13,0x02,0x55,
    0x53,0x31,0x0d,0x30,0x0b,0x06,0x03,0x55,0x04,0x0a,0x0c,0x04,0x52,0x6f,0x6b,0x75,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x0b,0x0c,0x02,0x4c,0x54,0x31,0x14,0x30,
    0x12,0x06,0x03,0x55,0x04,0x03,0x0c,0x0b,0x6c,0x74,0x2e,0x72,0x6f,0x6b,0x75,0x2e,0x63,0x6f,0x6d,0x30,0x59,0x30,0x13,0x06,0x07,0x2a,0x86,0x48,0xce,0x3d,0x02,0x01,
    0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x03,0x01,0x07,0x03,0x42,0x00,0x04,0xe0,0xbb,0xd0,0x45,0x6c,0x0a,0xd1,0x1d,0x59,0x46,0xc7,0x2f,0x66,0xa9,0x4a,0x54,0xa3,0x2c,
    0x0e,0x41,0x05,0x87,0x38,0x3a,0x0f,0x98,0x7a,0xed,0xb5,0x3f,0x22,0x13,0x8b,0xc2,0xc1,0xd9,0x63,0xc7,0x3d,0xc7,0x30,0xfe,0x7c,0x07,0x67,0xe4,0xb5,0xcc,0x55,0x57,
    0x87,0x6b,0xe9,0x3d,0x9f,0xee,0x2b,0x2f,0xdf,0x38,0xd4,0x70,0xa5,0x02,0xa3,0x81,0x8b,0x30,0x81,0x88,0x30,0x12,0x06,0x03,0x55,0x1d,0x13,0x01,0x01,0xff,0x04,0x08,
    0x30,0x06,0x01,0x01,0xff,0x02,0x01,0x02,0x30,0x1d,0x06,0x03,0x55,0x1d,0x0e,0x04,0x16,0x04,0x14,0xab,0x5c,0x66,0x97,0xea,0xc8,0x69,0xb1,0x37,0x5b,0xb0,0x95,0x3f,
    0x59,0x3e,0x7b,0x55,0x5f,0x11,0x4b,0x30,0x1f,0x06,0x03,0x55,0x1d,0x23,0x04,0x18,0x30,0x16,0x80,0x14,0xab,0x5c,0x66,0x97,0xea,0xc8,0x69,0xb1,0x37,0x5b,0xb0,0x95,
    0x3f,0x59,0x3e,0x7b,0x55,0x5f,0x11,0x4b,0x30,0x1d,0x06,0x03,0x55,0x1d,0x25,0x04,0x16,0x30,0x14,0x06,0x08,0x2b,0x06,0x01,0x05,0x05,0x07,0x03,0x01,0x06,0x08,0x2b,
    0x06,0x01,0x05,0x05,0x07,0x03,0x02,0x30,0x13,0x06,0x03,0x55,0x1d,0x11,0x04,0x0c,0x30,0x0a,0x82,0x08,0x6c,0x74,0x73,0x65,0x72,0x76,0x65,0x72,0x30,0x0a,0x06,0x08,
    0x2a,0x86,0x48,0xce,0x3d,0x04,0x03,0x02,0x03,0x47,0x00,0x30,0x44,0x02,0x20,0x35,0xc8,0x7c,0x6f,0x46,0x23,0x50,0x34,0xa8,0xf1,0x40,0x86,0xa7,0x2f,0xd7,0xcb,0xaa,
    0x6e,0xc4,0x71,0xfc,0xfc,0xa9,0x9d,0xf1,0x3e,0x25,0x9f,0x1f,0x2e,0xbd,0xb6,0x02,0x20,0x5c,0xf6,0x8d,0xe5,0xed,0x4c,0x9c,0x24,0x8c,0xc2,0x09,0x40,0xd9,0xf0,0x97,
    0x74,0xdb,0x00,0xac,0xad,0xab,0x4e,0x66,0x65,0xd2,0xba,0x3c,0x4a,0x33,0x8a,0x68,0x47,
};

static const LTPublicKey s_RokuCaKey = {
    SIGNATURE_ECDSA_SECP256R1_SHA256,
    ECDSA_P256_PUBLICKEY_LENGTH,
    (u8 *)"\xe0\xbb\xd0\x45\x6c\x0a\xd1\x1d\x59\x46\xc7\x2f\x66\xa9\x4a\x54\xa3\x2c\x0e\x41\x05\x87\x38\x3a\x0f\x98\x7a\xed\xb5\x3f\x22\x13\x8b\xc2\xc1\xd9\x63\xc7\x3d\xc7\x30\xfe\x7c\x07\x67\xe4\xb5\xcc\x55\x57\x87\x6b\xe9\x3d\x9f\xee\x2b\x2f\xdf\x38\xd4\x70\xa5\x02",
    SHA1_HASH_LENGTH,
    (u8 *)"\x8F\xBE\x3B\x01\x56\x02\xA5\x24\x14\xD1\x18\xF4\x34\x84\x34\x1C\x81\x85\x6D\xA2",
};
#endif

// Test client comm certificate, private and public keys
static const u8 s_ClientCertificate_ecdsa[] = {
    /* comm cert */
    0x00,0x01,0xf8,  /* cert length */
    0x30,0x82,0x01,0xf4,0x30,0x82,0x01,0x99,0xa0,0x03,0x02,0x01,0x02,0x02,0x14,0x1b,0x41,0x10,0xea,0x45,0x9e,0x3c,0x74,0x3e,0x20,0x59,0x2c,0x66,0x8a,0x67,0xb4,0x1a,
    0x5d,0x85,0x5e,0x30,0x0a,0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x04,0x03,0x02,0x30,0x48,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x06,0x13,0x02,0x55,0x53,0x31,0x0d,
    0x30,0x0b,0x06,0x03,0x55,0x04,0x0a,0x0c,0x04,0x52,0x6f,0x6b,0x75,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x0b,0x0c,0x02,0x4c,0x54,0x31,0x1d,0x30,0x1b,0x06,0x03,
    0x55,0x04,0x03,0x0c,0x14,0x53,0x30,0x58,0x37,0x30,0x33,0x31,0x39,0x52,0x38,0x37,0x54,0x31,0x33,0x46,0x35,0x43,0x35,0x35,0x34,0x30,0x20,0x17,0x0d,0x32,0x34,0x31,
    0x30,0x31,0x35,0x31,0x37,0x35,0x34,0x35,0x30,0x5a,0x18,0x0f,0x32,0x30,0x35,0x32,0x30,0x33,0x30,0x31,0x31,0x37,0x35,0x34,0x35,0x30,0x5a,0x30,0x4d,0x31,0x0b,0x30,
    0x09,0x06,0x03,0x55,0x04,0x06,0x13,0x02,0x55,0x53,0x31,0x0d,0x30,0x0b,0x06,0x03,0x55,0x04,0x0a,0x0c,0x04,0x52,0x6f,0x6b,0x75,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,
    0x04,0x0b,0x0c,0x02,0x4c,0x54,0x31,0x22,0x30,0x20,0x06,0x03,0x55,0x04,0x03,0x0c,0x19,0x53,0x30,0x58,0x37,0x30,0x33,0x31,0x39,0x52,0x38,0x37,0x54,0x31,0x33,0x46,
    0x35,0x43,0x35,0x35,0x34,0x2d,0x43,0x4f,0x4d,0x4d,0x30,0x59,0x30,0x13,0x06,0x07,0x2a,0x86,0x48,0xce,0x3d,0x02,0x01,0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x03,0x01,
    0x07,0x03,0x42,0x00,0x04,0xb2,0x80,0x0e,0xfb,0xc2,0x56,0x74,0x82,0x40,0xb1,0xbd,0xa7,0x09,0x19,0xd0,0xeb,0x87,0x2e,0x6b,0x2c,0xa3,0xd2,0x5f,0xfb,0xd2,0xbf,0x15,
    0x83,0xf5,0xd7,0x30,0x5c,0x13,0x48,0x59,0x6d,0x3b,0x70,0x37,0x55,0x4d,0xe6,0xbb,0xf8,0x5f,0x6b,0x57,0x97,0x2d,0xd7,0x6f,0xac,0xd0,0x6f,0xdb,0xb4,0x9a,0x26,0x72,
    0x9a,0x43,0xf6,0x1a,0x2d,0xa3,0x5a,0x30,0x58,0x30,0x09,0x06,0x03,0x55,0x1d,0x13,0x04,0x02,0x30,0x00,0x30,0x1d,0x06,0x03,0x55,0x1d,0x0e,0x04,0x16,0x04,0x14,0xbb,
    0x76,0xc6,0x31,0x92,0xd2,0xdf,0xad,0xbc,0x26,0x81,0xb1,0xe5,0x98,0xfc,0xea,0x13,0xc3,0x1b,0x44,0x30,0x1f,0x06,0x03,0x55,0x1d,0x23,0x04,0x18,0x30,0x16,0x80,0x14,
    0x67,0x2b,0xe4,0x18,0x19,0xda,0xd9,0x41,0x3f,0x75,0x39,0xaf,0x7f,0x0a,0x69,0xe4,0x4f,0x77,0x8f,0xfe,0x30,0x0b,0x06,0x03,0x55,0x1d,0x0f,0x04,0x04,0x03,0x02,0x05,
    0xa0,0x30,0x0a,0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x04,0x03,0x02,0x03,0x49,0x00,0x30,0x46,0x02,0x21,0x00,0xa1,0x3c,0x68,0xd6,0x54,0x76,0x52,0x6f,0x0f,0x30,0x9d,
    0xec,0x82,0x32,0x3f,0x2f,0xcd,0xc7,0xd8,0xff,0xfd,0xdf,0x4d,0x2e,0x8e,0x2e,0x22,0x4f,0xfc,0xd8,0x1e,0xb7,0x02,0x21,0x00,0xbf,0xc1,0x14,0x58,0x33,0x96,0x47,0x7a,
    0xb1,0x22,0x35,0x90,0x51,0x44,0x6b,0xb4,0xea,0xba,0x99,0xb0,0x8e,0x23,0xc1,0x8f,0x3e,0x65,0x45,0x5b,0xa9,0x0b,0x6c,0xe3,
    0x00,0x00,   /* extension length */
    /* id cert */
    0x00,0x02,0x1b,  /* cert length */
    0x30,0x82,0x02,0x17,0x30,0x82,0x01,0xbd,0xa0,0x03,0x02,0x01,0x02,0x02,0x14,0x43,0x33,0xdc,0xca,0x44,0x8d,0x8f,0x0c,0x4e,0x65,0x11,0x7e,0x68,0x30,0x18,0x01,0xf6,
    0x00,0x48,0x2c,0x30,0x0a,0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x04,0x03,0x02,0x30,0x40,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x06,0x13,0x02,0x55,0x53,0x31,0x0d,
    0x30,0x0b,0x06,0x03,0x55,0x04,0x0a,0x0c,0x04,0x52,0x6f,0x6b,0x75,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x0b,0x0c,0x02,0x4c,0x54,0x31,0x15,0x30,0x13,0x06,0x03,
    0x55,0x04,0x03,0x0c,0x0c,0x6d,0x69,0x64,0x2e,0x72,0x6f,0x6b,0x75,0x2e,0x63,0x6f,0x6d,0x30,0x20,0x17,0x0d,0x32,0x34,0x31,0x30,0x31,0x35,0x31,0x37,0x34,0x39,0x31,
    0x38,0x5a,0x18,0x0f,0x32,0x30,0x35,0x32,0x30,0x33,0x30,0x31,0x31,0x37,0x34,0x39,0x31,0x38,0x5a,0x30,0x48,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x06,0x13,0x02,
    0x55,0x53,0x31,0x0d,0x30,0x0b,0x06,0x03,0x55,0x04,0x0a,0x0c,0x04,0x52,0x6f,0x6b,0x75,0x31,0x0b,0x30,0x09,0x06,0x03,0x55,0x04,0x0b,0x0c,0x02,0x4c,0x54,0x31,0x1d,
    0x30,0x1b,0x06,0x03,0x55,0x04,0x03,0x0c,0x14,0x53,0x30,0x58,0x37,0x30,0x33,0x31,0x39,0x52,0x38,0x37,0x54,0x31,0x33,0x46,0x35,0x43,0x35,0x35,0x34,0x30,0x59,0x30,
    0x13,0x06,0x07,0x2a,0x86,0x48,0xce,0x3d,0x02,0x01,0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x03,0x01,0x07,0x03,0x42,0x00,0x04,0x80,0xd7,0x22,0xcf,0x65,0x26,0xf1,0x72,
    0xd0,0x61,0x98,0xfc,0xaf,0x54,0xb7,0xee,0xa2,0xc6,0xd4,0x40,0xe9,0x0a,0xb2,0xf5,0x7f,0xe6,0xfa,0xce,0xca,0xf9,0xf7,0x88,0x83,0x23,0xfd,0x50,0x42,0xd6,0x02,0x5b,
    0x31,0x78,0x1a,0x12,0xb9,0x57,0x39,0x0a,0x13,0x2e,0x8f,0x6c,0x55,0x63,0xc0,0x4d,0xf6,0xa4,0x92,0x2e,0xea,0x7b,0xdc,0x73,0xa3,0x81,0x8a,0x30,0x81,0x87,0x30,0x0f,
    0x06,0x03,0x55,0x1d,0x13,0x01,0x01,0xff,0x04,0x05,0x30,0x03,0x01,0x01,0xff,0x30,0x1d,0x06,0x03,0x55,0x1d,0x0e,0x04,0x16,0x04,0x14,0x67,0x2b,0xe4,0x18,0x19,0xda,
    0xd9,0x41,0x3f,0x75,0x39,0xaf,0x7f,0x0a,0x69,0xe4,0x4f,0x77,0x8f,0xfe,0x30,0x1f,0x06,0x03,0x55,0x1d,0x23,0x04,0x18,0x30,0x16,0x80,0x14,0x29,0x8f,0xd8,0xcc,0xa5,
    0xbd,0x2b,0x29,0x6a,0x81,0xbc,0x8a,0x9d,0x32,0xa1,0x70,0x7e,0x18,0x51,0x49,0x30,0x0e,0x06,0x03,0x55,0x1d,0x0f,0x01,0x01,0xff,0x04,0x04,0x03,0x02,0x02,0x04,0x30,
    0x13,0x06,0x03,0x55,0x1d,0x25,0x04,0x0c,0x30,0x0a,0x06,0x08,0x2b,0x06,0x01,0x05,0x05,0x07,0x03,0x02,0x30,0x0f,0x06,0x03,0x55,0x1d,0x11,0x04,0x08,0x30,0x06,0x82,
    0x04,0x69,0x64,0x63,0x61,0x30,0x0a,0x06,0x08,0x2a,0x86,0x48,0xce,0x3d,0x04,0x03,0x02,0x03,0x48,0x00,0x30,0x45,0x02,0x21,0x00,0xcd,0xbc,0x4f,0x3a,0x96,0x77,0x43,
    0x3f,0xea,0xc3,0xa5,0x41,0x28,0x8c,0x6d,0x71,0x04,0xd1,0x88,0xf0,0x92,0x7f,0xcd,0x60,0x9f,0x93,0x57,0x95,0x0a,0x91,0xcc,0xda,0x02,0x20,0x25,0xde,0x5f,0x94,0x2c,
    0x9c,0x22,0x15,0x19,0x65,0x93,0x3f,0xcd,0xac,0x4f,0x02,0x9e,0x4f,0x88,0xf7,0x48,0x00,0x21,0x47,0x88,0xbb,0x19,0xfe,0xb5,0x43,0x2e,0xb6,
    0x00,0x00,   /* extension length */
};

static const LTPublicKey s_ClientPublicKey_ecdsa = {
    SIGNATURE_ECDSA_SECP256R1_SHA256,
    ECDSA_P256_PUBLICKEY_LENGTH,
    (u8 *)"\xb2\x80\x0e\xfb\xc2\x56\x74\x82\x40\xb1\xbd\xa7\x09\x19\xd0\xeb\x87\x2e\x6b\x2c\xa3\xd2\x5f\xfb\xd2\xbf\x15\x83\xf5\xd7\x30\x5c\x13\x48\x59\x6d\x3b\x70\x37\x55\x4d\xe6\xbb\xf8\x5f\x6b\x57\x97\x2d\xd7\x6f\xac\xd0\x6f\xdb\xb4\x9a\x26\x72\x9a\x43\xf6\x1a\x2d",
    0,
    NULL,
};

static const LTPrivateKey s_ClientPrivateKey_ecdsa = {
    SIGNATURE_ECDSA_SECP256R1_SHA256,
    ECDSA_P256_PRIVATEKEY_LENGTH,
    (u8 *)"\xee\xc9\x59\xbb\xb9\xac\xb6\xd8\x55\x52\x55\x7f\x00\x63\x7d\xbc\x4f\x1b\x8b\x81\xf7\x48\x1a\x81\x6d\xed\x73\xb1\xa1\xc7\xc2\xfb",
};

void TestKeyObjects(Tilt *tilt) {
    LTDriverCryptoKeyManager *keyManager1 = lt_createobject(LTDriverCryptoKeyManager);
    TILT_EXPECT_TRUE(tilt, keyManager1 != NULL, "key manager 1 fail");
    LTDriverCryptoKeyManager *keyManager2 = lt_createobject(LTDriverCryptoKeyManager);
    TILT_EXPECT_TRUE(tilt, keyManager2 != NULL, "key manager 2 fail");
    lt_destroyobject(keyManager1);
    lt_destroyobject(keyManager2);
}

void TestPublicKey(Tilt *tilt) {
    LTDriverCryptoKeyManager *keyManager = lt_createobject(LTDriverCryptoKeyManager);
    LTDriverCryptoCertManager *certManager = lt_createobject(LTDriverCryptoCertManager);
    TILT_EXPECT_TRUE(tilt, certManager->API->SetCertificate("ROKUCA", s_RokuCa, sizeof(s_RokuCa), false, true), "Set ROKUCA cert fail");
    TILT_EXPECT_TRUE(tilt, certManager->API->SetCertificate("comm", (u8 *)&s_ClientCertificate_ecdsa, sizeof(s_ClientCertificate_ecdsa), true, true), "Set comm cert fail");

    LTPublicKey publicKey;
    lt_memset(&publicKey, 0, sizeof(LTPublicKey));
    TILT_INFO(tilt, "Test public key");
    TILT_EXPECT_TRUE(tilt, keyManager->API->SetPublicKey("comm", &s_ClientPublicKey_ecdsa, false), "Set comm key fail");
    TILT_EXPECT_TRUE(tilt, keyManager->API->GetPublicKey("comm", &publicKey), "Get comm key fail");
    TILT_EXPECT_TRUE(tilt, s_ClientPublicKey_ecdsa.type == publicKey.type, "comm key type mismatch");
    TILT_EXPECT_TRUE(tilt, s_ClientPublicKey_ecdsa.keyLen == publicKey.keyLen, "comm key len mismatch");
    TILT_EXPECT_TRUE(tilt, s_ClientPublicKey_ecdsa.keyIdLen == publicKey.keyIdLen, "Comm key id len mismatch");
    TILT_EXPECT_TRUE(tilt, lt_memcmp(s_ClientPublicKey_ecdsa.key, publicKey.key, publicKey.keyLen) == 0, "comm key mismatch");
    TILT_EXPECT_TRUE(tilt, lt_memcmp(s_ClientPublicKey_ecdsa.keyId, publicKey.keyId, publicKey.keyIdLen) == 0, "comm key id mismatch");
    keyManager->API->FreePublicKey(&publicKey);

    TILT_INFO(tilt, "Test CA key");
    TILT_EXPECT_TRUE(tilt, keyManager->API->SetCaPublicKey("ROKUCA", &s_RokuCaKey, false), "Set CA key fail");
    TILT_EXPECT_TRUE(tilt, keyManager->API->GetCaPublicKey("ROKUCA", &publicKey), "Get CA key fail");
    TILT_EXPECT_TRUE(tilt, s_RokuCaKey.type == publicKey.type, "CA key type mismatch");
    TILT_EXPECT_TRUE(tilt, s_RokuCaKey.keyLen == publicKey.keyLen, "CA key len mismatch");
    TILT_EXPECT_TRUE(tilt, s_RokuCaKey.keyIdLen == publicKey.keyIdLen, "CA key id len mismatch");
    TILT_EXPECT_TRUE(tilt, lt_memcmp(s_RokuCaKey.key, publicKey.key, publicKey.keyLen) == 0, "CA key mismatch");
    TILT_EXPECT_TRUE(tilt, lt_memcmp(s_RokuCaKey.keyId, publicKey.keyId, publicKey.keyIdLen) == 0, "CA key id mismatch");
    keyManager->API->FreePublicKey(&publicKey);

    lt_destroyobject(certManager);
    lt_destroyobject(keyManager);
}

void TestPrivateKey(Tilt *tilt) {
    LTDriverCryptoKeyManager *keyManager = lt_createobject(LTDriverCryptoKeyManager);
    LTDriverCryptoCertManager *certManager = lt_createobject(LTDriverCryptoCertManager);

    TILT_INFO(tilt, "Test client cert");
    TILT_EXPECT_TRUE(tilt, certManager->API->SetCertificate("comm", (u8 *)&s_ClientCertificate_ecdsa, sizeof(s_ClientCertificate_ecdsa), true, true), "Set comm cert fail");

    TILT_INFO(tilt, "Test private key");
    TILT_EXPECT_TRUE(tilt, keyManager->API->SetPrivateKey("comm", &s_ClientPrivateKey_ecdsa, true), "Set comm key fail");

    TILT_INFO(tilt, "Test private key reference");
    LTDriverCrypto_KeyReference *keyReference = keyManager->API->GetPrivateKeyReference("comm");
    TILT_EXPECT_TRUE(tilt, kLTDriverCrypto_ProvisionId_CommPrivate == keyReference->provisionId, "Wrong comm key ID %u != %u", kLTDriverCrypto_ProvisionId_CommPrivate, keyReference->provisionId);
    TILT_EXPECT_TRUE(tilt, kLTDriverCrypto_KeyType_P256 == keyReference->keyType, "Wrong comm key type %u != %u", kLTDriverCrypto_KeyType_P256, keyReference->keyType);
    keyManager->API->FreeKeyReference(keyReference);

    lt_destroyobject(certManager);
    lt_destroyobject(keyManager);
}

void TestSecureCryptos(Tilt *tilt) {
    // Secure key manager
    LTSecureKeyManager *secKeyManager = lt_createobject(LTSecureKeyManager);
    if (secKeyManager) {
        TILT_INFO(tilt, "Test secure key manager");
        LTDriverCrypto_KeyReference *reference = secKeyManager->API->SetKey(k78, AES128_KEY_LENGTH, kLTDriverCrypto_KeyType_Key128, kLTDriverCrypto_SecureKeyType_Wrapped);
        if (reference) {
            PrintBytes(tilt, reference->referenceBuf, 0, reference->referenceLen);
            // Secure CBC
            TILT_INFO(tilt, "Test secure Aes128Cbc");
            LTSecureCryptoAes128Cbc *aescbc = lt_createobject(LTSecureCryptoAes128Cbc);
            if (aescbc) {
                LTSystemCryptoResult result = aescbc->API->Encrypt(reference, iv78, p78, sizeof(p78), s_output);
                TILT_EXPECT_TRUE(tilt, (kLTSystemCrypto_Result_Ok == result) && (lt_memcmp(s_output, ec78, sizeof(ec78)) == 0), "Encrypt error");
                result = aescbc->API->Decrypt(reference, iv78, ec78, sizeof(ec78), s_output);
                TILT_EXPECT_TRUE(tilt, (kLTSystemCrypto_Result_Ok == result) && (lt_memcmp(s_output, p78, sizeof(p78)) == 0), "Decrypt error");
                secKeyManager->API->FreeKeyReference(reference);
                lt_destroyobject(secKeyManager);
            } else {
                TILT_WARNING(tilt, "No support of secure aes128-cbc !!!");
            }
        } else {
            TILT_WARNING(tilt, "No support of wrap crypto !!!");
        }
    } else {
        TILT_WARNING(tilt, "No support of secure key manager !!!");
    }

    LTDeviceIdentity *identity = lt_openlibrary(LTDeviceIdentity);
    u8 key[AES128_KEY_LENGTH];
    if (identity->GetAESKey(key, 1)) {
        LTDriverCrypto_KeyReference keyReference;
        keyReference.secureKeyType = kLTDriverCrypto_SecureKeyType_Provision;
        LTSystemCryptoResult result = kLTSystemCrypto_Result_Ok;

        TILT_INFO(tilt, "Test secure Aes128Cbc");
        LTSecureCryptoAes128Cbc *aescbc = lt_createobject(LTSecureCryptoAes128Cbc);
        if (aescbc) {
            keyReference.keyType = kLTDriverCrypto_KeyType_Key128;
            keyReference.provisionId = kLTDriverCrypto_ProvisionId_AesKey1;
            result = aescbc->API->Encrypt(&keyReference, iv78, p78, sizeof(p78), s_output);
            if (kLTSystemCrypto_Result_NoSupport == result) {
                TILT_WARNING(tilt, "No support of secure aes128-cbc on provisioned aes keys !!!");
            } else {
                TILT_EXPECT_TRUE(tilt, (kLTSystemCrypto_Result_Ok == result), "encrypt fail");
                result = aescbc->API->Decrypt(&keyReference, iv78, s_output, sizeof(p78), s_output);
                TILT_EXPECT_TRUE(tilt, (kLTSystemCrypto_Result_Ok == result) && (lt_memcmp(s_output, p78, sizeof(p78)) == 0), "decrypt fail");
            }
            lt_destroyobject(secKeyManager);
        } else {
            TILT_WARNING(tilt, "No support of secure aes128-cbc !!!");
        }

        TILT_INFO(tilt, "Test secure HmacSha256");
        LTSecureCryptoHmacSha256 *secHmac = lt_createobject(LTSecureCryptoHmacSha256);
        if (secHmac) {
            keyReference.keyType = kLTDriverCrypto_KeyType_Key128;
            keyReference.provisionId = kLTDriverCrypto_ProvisionId_AesKey1;
            result = secHmac->API->GenHmac(&keyReference, (u8 *)"key1", 4, s_output);
            TILT_EXPECT_TRUE(tilt, kLTSystemCrypto_Result_Ok == result, "hmac key1 fail %d", result);
            keyReference.provisionId = kLTDriverCrypto_ProvisionId_AesKey2;
            result = secHmac->API->GenHmac(&keyReference, (u8 *)"key2", 4, s_output);
            TILT_EXPECT_TRUE(tilt, kLTSystemCrypto_Result_Ok == result, "hmac key2 fail %d", result);
            lt_destroyobject(secHmac);
        } else {
            TILT_WARNING(tilt, "No support of secure hmac-sha256 !!!");
        }

        TILT_INFO(tilt, "Test secure Sha256");
        LTSecureCryptoSha256 *secSha = lt_createobject(LTSecureCryptoSha256);
        if (secSha) {
            keyReference.provisionId = kLTDriverCrypto_ProvisionId_AesKey1;
            result = secSha->API->GenDigest(&keyReference, (u8 *)"key1", 4, s_output);
            TILT_EXPECT_TRUE(tilt, kLTSystemCrypto_Result_Ok == result, "sha key1 fail %d", result);
            keyReference.provisionId = kLTDriverCrypto_ProvisionId_AesKey2;
            result = secSha->API->GenDigest(&keyReference, (u8 *)"key2", 4, s_output);
            TILT_EXPECT_TRUE(tilt, kLTSystemCrypto_Result_Ok == result, "sha key2 fail %d", result);
            lt_destroyobject(secSha);
        } else {
            TILT_WARNING(tilt, "No support of secure sha256 !!!");
        }

        TILT_INFO(tilt, "Test secure EcdsaP256");
        LTSecureCryptoEcdsaP256 *secEcdsa = lt_createobject(LTSecureCryptoEcdsaP256);
        if (secEcdsa) {
            const u8 data[] = "data";
            keyReference.keyType = kLTDriverCrypto_KeyType_P256;
            keyReference.provisionId = kLTDriverCrypto_ProvisionId_CommPrivate;
            secEcdsa->API->Sign(&keyReference, data, sizeof(data), s_output, s_output + ECDSA_P256_SIGNATURE_LENGTH);
            LTSystemCryptoResult ret = secEcdsa->API->Verify(data, sizeof(data), s_output, s_output + ECDSA_P256_SIGNATURE_LENGTH);
            TILT_EXPECT_TRUE(tilt, kLTSystemCrypto_Result_Ok == ret, "wrong signature %d", ret);
            lt_destroyobject(secEcdsa);
        } else {
            TILT_WARNING(tilt, "No support of secure ecdsaP256 !!!");
        }

    } else {
        TILT_WARNING(tilt, "No key to test !!!");
    }
    lt_closelibrary(identity);
}

static void BeforeAllTests(Tilt *tilt) {
    LT_UNUSED(tilt);
    // Keep these two libs open to avoid init/fini in underlying crypto and flash drivers.
    s_crypto = lt_openlibrary(LTSystemCrypto);
    s_settings = lt_openlibrary(LTSystemSettings);
}

static void AfterAllTests(Tilt *tilt) {
    LT_UNUSED(tilt);
    // Flush settings (if needed) before exiting test
    s_settings->Flush(NULL);
    lt_closelibrary(s_settings);
    lt_closelibrary(s_crypto);
}

static const TiltEngineTestHooks s_hooks = {
    .BeforeAllTests = BeforeAllTests,
    .AfterAllTests  = AfterAllTests,
};

static const TiltEngineTest s_tests[] = {
    { TestKeyObjects,    "TestKeyObjects",    "Test multiple key objects",      0 },
    { TestPublicKey,     "TestPublicKey",     "Test public key operations",     0 },
    { TestPrivateKey,    "TestPrivateKey",    "Test private key operations",    0 },
    { TestSecureCryptos, "TestSecureCryptos", "Test secure cryptos",            0 },
};

static int UnitTestLTDeviceCryptoImpl_Run(int argc, const char **argv) {
    /* Set test properties */
    s_engine->API->ConfigureTestSuite(s_engine, s_tests, sizeof(s_tests)/sizeof(s_tests[0]), &s_hooks);

    /* Invoke testing */
    return s_engine->API->RunTestSuite(s_engine, argc, argv);
}

static bool UnitTestLTDeviceCryptoImpl_LibInit(void) {
    s_engine = lt_createobject(JiltEngine);
    return s_engine != NULL;
}

static void UnitTestLTDeviceCryptoImpl_LibFini(void) {
    lt_destroyobject(s_engine);
}

typedef_LTLIBRARY_ROOT_INTERFACE(UnitTestLTDeviceCrypto, 1) LTLIBRARY_EMPTY_INTERFACE;

define_LTLIBRARY_ROOT_INTERFACE(UnitTestLTDeviceCrypto, UnitTestLTDeviceCryptoImpl_Run, 1536) LTLIBRARY_DEFINITION;
